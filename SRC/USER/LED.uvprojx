# Keil uVision project LED.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LCD;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\USB\CONFIG;..\USB\STM32_USB-FS-Device_Driver\inc;..\HARDWARE\ADC;..\HARDWARE\IO
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LCD/: lcd.c lcdgpio.c
    ../HARDWARE/ADC/: ADC.c
    ../HARDWARE/IO/: IO.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_exti.c stm32f10x_adc.c
  group USB_CORE
    ../USB/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB_CONFIG
    ../USB/CONFIG/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
